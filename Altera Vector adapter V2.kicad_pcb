# Repository james10952001/FPGA-mini-vector-arcade

## KiCad design Altera Vector adapter V2.kicad_pcb

Parts:
C1: 100uF
C2, C3, C4, C5, C6, C11, C14, C15, C18, C19: 100n
C7: 4.7n
C8: 470n
C9: 1uF
C10: 4.7uF
C16, C17, C20: 10uF
J1: CONN_ALTERA_MIN_BRD_128
L1: CIC10J601NC
L2: 6.8uH
P1: Player 1
P2: Player 2
P3: Monitor
P4: Speaker
P5: I2C
R1, R2, R3: 75R
R4: 560R
R5: 3.3k
R6, R16, R17: 50k
R7, R8: 20k
R9, R10, R11, R12, R15: 10k
R13, R14: 2k
R18: 33k
R19: 1k
R20, R21: 4.7k
U1: LM4991
U2: ADV7123
U3: 39LF010_PLCC
U4: DC_DC_ISA
U5: TL082
U6: TL082
U7: LM4040
U8: 24C16

Connections:
+3.3V: C1.1, C2.1, C3.1, C10.1, C14.1, J1.PA27, J1.PA28, J1.PB28, J1.PC28, J1.PD27, J1.PD28, L1.1, L2.1, P5.1, R20.2, R21.2, U1.6 (Pwr), U2.11 (~BLANK), U2.38 (~PSAVE), U3.32 (VCC), U8.8 (VCC)
+3.3VADC: C4.1, C5.2, C6.2, L1.2, U2.13 (Vaa), U2.29 (Vaa), U2.30 (Vaa)
+15V: C15.1, C16.1, C18.1, U4.7 (+Vout), U5.8 (V+), U6.8 (V+)
-5V: C20.2, R10.1, R10.2, R12.1, R12.2, R19.1, U7.3 (A)
-15V: C11.1, C17.2, C19.1, R19.2, U4.5 (-Vout), U5.4 (V-), U6.4 (V-)
/A0: J1.PC7, U3.12 (A0)
/A1: J1.PC9, U3.11 (A1)
/A2: J1.PC11, U3.10 (A2)
/A3: J1.PC14, U3.9 (A3)
/A4: J1.PC13, U3.8 (A4)
/A5: J1.PC15, U3.7 (A5)
/A6: J1.PC18, U3.6 (A6)
/A7: J1.PC17, U3.5 (A7)
/A8: J1.PC21, U3.27 (A8)
/A9: J1.PC22, U3.26 (A9)
/A10: J1.PC20, U3.23 (A10)
/A11: J1.PC19, U3.25 (A11)
/A12: J1.PD18, U3.4 (A12)
/A13: J1.PC24, U3.28 (A13)
/A14: J1.PC23, U3.29 (A14)
/A15: J1.PD17, U3.3 (A15)
/A16: J1.PD15, U3.2 (A16)
/A17: J1.PD4, U3.30 (A17)
/A18: J1.PD6, U3.1 (A18)
/Audio: J1.PD16, R5.2
/CLK: J1.PA19, U2.24 (CLOCK)
/D0: J1.PC5, U3.13 (O0)
/D1: J1.PC4, U3.14 (O1)
/D2: J1.PC3, U3.15 (O2)
/D3: J1.PC6, U3.17 (O3)
/D4: J1.PC8, U3.18 (O4)
/D5: J1.PC10, U3.19 (O5)
/D6: J1.PC12, U3.20 (O6)
/D7: J1.PC16, U3.21 (O7)
/LED1: J1.PA1, P1.8
/LED2: J1.PA2, P1.9
/SCL: J1.PA18, P5.3, R21.1, U8.6 (SCL)
/SDA: J1.PA17, P5.2, R20.1, U8.5 (SDA)
/SW1: J1.PA16, P1.1
/SW2: J1.PA14, P1.2
/SW3: J1.PA12, P1.3
/SW4: J1.PA10, P1.4
/SW5: J1.PA8, P1.5
/SW6: J1.PA6, P1.6
/SW7: J1.PA4, P1.7
/SW8: J1.PA15, P2.10
/SW9: J1.PA13, P2.9
/SW10: J1.PA11, P2.8
/SW11: J1.PA9, P2.7
/SW12: J1.PA7, P2.6
/SW13: J1.PA5, P2.5
/SW14: J1.PA3, P2.4
/SW15: J1.PD22, P2.3
/Test: J1.PD21, P2.2
/X0: J1.PA20, U2.1 (G0)
/X1: J1.PB25, U2.2 (G1)
/X2: J1.PB23, U2.3 (G2)
/X3: J1.PB24, U2.4 (G3)
/X4: J1.PB21, U2.5 (G4)
/X5: J1.PB22, U2.6 (G5)
/X6: J1.PB19, U2.7 (G6)
/X7: J1.PB20, U2.8 (G7)
/X8: J1.PB17, U2.9 (G8)
/X9: J1.PB18, U2.10 (G9)
/Y0: J1.PB16, U2.14 (B0)
/Y1: J1.PB11, U2.15 (B1)
/Y2: J1.PB9, U2.16 (B2)
/Y3: J1.PB10, U2.17 (B3)
/Y4: J1.PB7, U2.18 (B4)
/Y5: J1.PB8, U2.19 (B5)
/Y6: J1.PB5, U2.20 (B6)
/Y7: J1.PB6, U2.21 (B7)
/Y8: J1.PB3, U2.22 (B8)
/Y9: J1.PB4, U2.23 (B9)
/Z0: J1.PA23, U2.45 (R6)
/Z1: J1.PA24, U2.46 (R7)
/Z2: J1.PA21, U2.47 (R8)
/Z3: J1.PA22, U2.48 (R9)
/~OE: J1.PD24, U3.24 (~OE)
/~WE: J1.PD23, U3.31 (~WE)
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C9.2, C10.2, C11.2, C14.2, C15.2, C16.2, C17.1, C18.2, C19.2, C20.1, J1.PA25, J1.PA26, J1.PB1, J1.PB2, J1.PB26, J1.PB27, J1.PC1, J1.PC2, J1.PC26, J1.PC27, J1.PD1, J1.PD2, J1.PD8, J1.PD9, J1.PD10, J1.PD25, J1.PD26, P1.10, P2.1, P3.2, P3.4, P3.6, P5.4, R1.1, R2.1, R3.1, R4.1, R6.1, R15.1, U1.1 (Shtdn), U1.7 (Gnd), U2.12 (~SYNC), U2.25 (GND), U2.26 (GND), U2.27 (~IOB), U2.31 (~IOG), U2.33 (~IOR), U2.39 (R0), U2.40 (R1), U2.41 (R2), U2.42 (R3), U2.43 (R4), U2.44 (R5), U3.16 (GND), U3.22 (~CE), U4.1 (Gnd), U4.4 (0Vout), U5.5 (+), U6.3 (+), U6.5 (+), U7.1 (K), U8.1 (A0), U8.2 (A1), U8.3 (A2), U8.4 (GND), U8.7 (WP)
unnamed: U5.6 (-), U5.7
unnamed: R15.2, R18.2, U5.2 (-)
unnamed: R7.1, R8.2, U1.4 (-)
unnamed: C9.1, U1.2 (Bypass), U1.3 (+)
unnamed: P4.1, U1.8 (VO1)
unnamed: C7.1, R5.1, R6.3
unnamed: C8.1, R6.2
unnamed: C8.2, R7.2
unnamed: P4.2 (PM), R8.1, U1.5 (VO2)
unnamed: R11.2, R12.3
unnamed: R9.2, R10.3
unnamed: R2.2, R13.2, U2.32 (IOG)
unnamed: R3.2, R14.2, U2.28 (IOB)
unnamed: C5.1, U2.36 (Vref)
unnamed: R4.2, U2.37 (Rset)
unnamed: R9.1, R13.1, R16.2, R16.3, U6.2 (-)
unnamed: P3.5, R16.1, U6.1
unnamed: L2.2, U4.2 (+Vin)
unnamed: R11.1, R14.1, R17.1, U6.6 (-)
unnamed: C6.1, U2.35 (Comp)
unnamed: R1.2, U2.34 (IOR), U5.3 (+)
unnamed: P3.3, R17.2, R17.3, U6.7
unnamed: P3.1, R18.1, U5.1

Notes on the sheet:
GND
Left
Right
Fire
Thrust
Shield
Start1
Start2
Coin1
Coin2
Test

Board: 2 copper layers, 51.8 x 71.7 mm, 57 parts (0 on the bottom side), 104 nets.

Other parts of the board:
3362P: VAL**; Bourns_3362P
VAL: REF; cat_300

## Commit log

2018-11-10 Initial public release
    This board plugs into the Cyclone II mini board I've used in many other projects. It holds a DAC that can produce the X, Y and Z signals necessary to drive a B&W vector monitor along with the associa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

Notices in the files:
Altera Vector adapter V2.kicad_pcb:
(c) 2016 James Sweet
